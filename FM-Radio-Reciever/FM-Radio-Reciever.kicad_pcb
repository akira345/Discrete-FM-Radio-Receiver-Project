# Repository akira345/Discrete-FM-Radio-Receiver-Project (continued)

## KiCad design MPXDecorder-V4_SMD/MPXDecorder-V4_SMD.kicad_pcb (continued)

Board: 4 copper layers, 73.5 x 73.6 mm, 119 parts (25 on the bottom side), 71 nets.

File MPXDecorder-V4_SMD/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C10, C3, C42, C43, C5",0603,5,1u,
"C13, C14, C17, C18, C19, C24, C25, C26, C38, C40, C7",0603,11,0.1u,
"C20, C21",0603,2,470p,
"C22, C23",0603,2,390p,
"C27, C28",0603,2,4700p,
"C29, C30",0603,2,1200p,
"C31, C32",0603,2,180p,
C33,CP_Elec_10x10,1,330u 25v,
"C34, C35",1206,2,10u,
"C36, C37",0603,2,220p,
C4,0603,1,1n,
C41,0805,1,1n,
C50,1206,1,33n,
D2,0603,1,STEREO-LED,
J1,PinHeader_1x03_P2.54mm_Vertical,1,MPX-IN,
J2,PinHeader_1x03_P2.54mm_Vertical,1,OUT-L,
"J3, J5, J7",PinHeader_1x03_P2.54mm_Vertical,3,GND,
J4,PinHeader_1x03_P2.54mm_Vertical,1,OUT-R,
J6,PinHeader_1x03_P2.54mm_Vertical,1,5V,
"Q3, Q4, Q5, Q6",SOT-23_Handsoldering,4,2N3904,
R1,0603,1,120k,
"R12, R13, R22, R23, R4, R5",0603,6,100k,
R2,0603,1,300k,
"R24, R28, R30, R31",0603,4,1k,
"R33, R34, R35, R36, R38, R39, R44, R45, R46, R47, R48, R49, R52, R53, R60, R61, R62, R66, R67, R68, R72, R81, R82, R83",0603,24,10k,
"R40, R41, R42, R43, R50, R51, R54, R55",0603,8,22k,
R58,0603,1,1.5k,
"R63, R84",0603,2,47k,
R64,0603,1,68k,
R69,0603,1,2.2Meg,
R70,0603,1,4.7Meg,
R71,0603,1,15k,
R80,0603,1,27k,
R85,0603,1,2.2k,
RV1,Potentiometer_Bourns_TC33X_Vertical,1,50k,
RV2,Potentiometer_Bourns_TC33X_Vertical,1,2.2k,
TP10,TestPoint_Pad_2.5x2.5mm,1,Quadrature-phase,
TP11,TestPoint_Pad_2.5x2.5mm,1,COMP,
TP12,TestPoint_Pad_2.5x2.5mm,1,VCTL,
TP3,TestPoint_Pad_2.5x2.5mm,1,38KHz-PLL,
TP5,TestPoint_Pad_2.5x2.5mm,1,VCO,
TP6,TestPoint_Pad_2.5x2.5mm,1,VCO_IN,
TP7,TestPoint_Pad_2.5x2.5mm,1,SA,
TP8,TestPoint_Pad_2.5x2.5mm,1,SB,
TP9,TestPoint_Pad_2.5x2.5mm,1,PD,
"U1, U8",SO-14_5.3x10.2mm_P1.27mm,2,TC4066BFELNF,
"U2, U6, U7",SSOP-14_5.3x6.2mm_P0.65mm,3,NJM2747V,
U3,TSSOP-16_4.4x5mm_P0.65mm,1,74HC4046APW,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,LM393,
"U5, U9",SOIC-14_3.9x8.7mm_P1.27mm,2,74HC74D,

## KiCad design MPXDecorder/MPXDecorder.kicad_pcb

Board: 2 copper layers, 100.0 x 84.2 mm, 104 parts (56 on the bottom side), 66 nets.

Parts:
C1, C18, C24, C30: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C3, C4, C5: 0.01u; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C6, C7, C9, C19, C25, C26, C27, C28, C29, C31: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C11, C13, C14, C20, C21, C22, C23: 3.3n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12, C15, C16, C17: 10u; C_1210_3225Metric_Pad1.33x2.70mm_HandSolder
C33: 330u 25v; CP_Elec_10x10
D1: 1s1588; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: STEREO-LED; LED_D3.0mm
J1: MPX-IN; PinHeader_1x03_P2.54mm_Vertical
J2: OUT-L; PinHeader_1x03_P2.54mm_Vertical
J3: OUT-R; PinHeader_1x03_P2.54mm_Vertical
J4, J6, J7: GND; PinHeader_1x03_P2.54mm_Vertical
J5: 5V; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2: 2SC1815; TO-92_Inline
R1, R3: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R4: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R13, R17, R18, R24, R25, R32, R33: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R9, R10, R21, R43, R44, R45: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R46: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R14: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R16: 39; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R20, R22, R23, R26, R27, R30, R31: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29: 1.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34, R35, R36, R37, R38, R39, R40, R41, R42: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 2k; Potentiometer_Bourns_3386P_Vertical
TP1: 19KHz-Sin; PinHeader_1x01_P1.00mm_Vertical
TP2: 19KHz-Rect; PinHeader_1x01_P1.00mm_Vertical
TP3: 38KHz-PLL; PinHeader_1x01_P1.00mm_Vertical
TP4: L+R; PinHeader_1x01_P1.00mm_Vertical
TP5: L-R; PinHeader_1x01_P1.00mm_Vertical
TP6: PILOT-V; PinHeader_1x01_P1.00mm_Vertical
TP7: VCO; PinHeader_1x01_P1.00mm_Vertical
U2: LM393; DIP-8_W7.62mm_Socket_LongPads
U3: 4046; DIP-16_W7.62mm_Socket_LongPads
U4: 74HC74; DIP-14_W7.62mm_Socket_LongPads
U5, U8, U9: HA17902; DIP-14_W7.62mm_Socket_LongPads
U6: CD4066BE; DIP-14_W7.62mm_Socket_LongPads

Connections:
+5V: C19.1, C25.1, C26.1, C27.1, C28.1, C29.1, C31.1, C33.1, J5.1, J5.2, J5.3, R5.1, R9.1, R10.1, R17.1, R24.1, R28.1, R32.1, R43.1, R45.1, U2.8 (V+), U3.16 (VDD), U4.14 (VCC), U5.4 (V+), U6.4, U6.14 (V_{DD}), U8.4 (V+), U9.4 (V+)
/19KHzRect: R10.2, TP2.1 (1_1), U2.1, U3.14 (SigIn)
/19KHzSin: C4.2, C6.1, C7.1, R4.2, TP1.1 (1_1), U9.7
/38KHz-PLL: TP3.1 (1_1), U4.5 (Q), U4.11 (C), U6.13
/L+R: C12.2, R34.1, R41.1, TP4.1 (1_1)
/L-R: C15.2, R35.1, R40.1, TP5.1 (1_1), U6.8
/MPX: C1.1, C9.1, J1.1, J1.2, J1.3
/OUT-L: C16.2, J2.1, J2.2, J2.3
/OUT-R: C17.2, J3.1, J3.2, J3.3
/PILOT-V: C30.1, R11.2, TP6.1 (1_1), U2.5 (+)
/VCO: TP7.1 (1_1), U3.4 (FOUT), U4.3 (C)
GND: C11.1, C13.1, C18.2, C19.2, C20.1, C22.1, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C33.2, D2.1 (K), J4.1, J4.2, J4.3, J6.1, J6.2, J6.3, J7.1, J7.2, J7.3, Q1.1 (E), Q2.1 (E), R6.2, R13.2, R15.2, R16.2, R18.2, R25.2, R29.2, R33.2, RV1.3, U2.4 (V-), U3.8 (VSS), U4.7 (GND), U5.11 (V-), U6.7 (V_{SS}), U6.9, U6.10, U6.11, U6.12, U8.11 (V-), U9.11 (V-)
unnamed: C2.1, C3.1, R1.2, R15.1
unnamed: C3.2, R2.2, R3.1, U9.1
unnamed: C4.1, C5.1, R3.2, R16.1
unnamed: C7.2, R7.1
unnamed: C9.2, R1.1
unnamed: C10.1, R19.2, R20.1
unnamed: C14.1, R22.2, R23.1
unnamed: C16.1, R38.2, U8.14
unnamed: C17.1, R39.2, U8.8
unnamed: C21.1, R26.2, R27.1
unnamed: C23.1, R30.2, R31.1
unnamed: D1.2 (A), Q1.2 (C), R8.1, R9.2
unnamed: D1.1 (K), R11.1
unnamed: D2.2 (A), R46.2
unnamed: Q1.3 (B), R7.2, R8.2
unnamed: Q2.3 (B), R44.2
unnamed: Q2.2 (C), R45.2, U6.6
unnamed: R14.2, RV1.1, RV1.2
unnamed: R21.2, U6.1
unnamed: R22.1, U6.2
unnamed: R36.2, R37.1, U8.7
unnamed: R43.2, R44.1, U2.7, U6.5
unnamed: R46.1, U6.3
unnamed: C6.2, R5.2, R6.1, U2.3 (+)
unnamed: U2.2 (-), U9.2 (-), U9.6 (-), U9.13 (-), U9.14
unnamed: R28.2, R29.1, U2.6 (-)
unnamed: C8.1, U3.6 (C1)
unnamed: C8.2, U3.7 (C2)
unnamed: R12.1, U3.13 (PC2)
unnamed: R14.1, U3.11 (R1)
unnamed: R13.1, U3.12 (R2)
unnamed: U3.3 (RefIn), U4.9 (Q)
unnamed: R12.2, U3.9 (VCOin)
unnamed: U4.2 (D), U4.6 (~Q)
unnamed: U4.8 (~Q), U4.12 (D)
unnamed: C11.2, R20.2, U5.3 (+)
unnamed: C10.2, R26.1, U5.1, U5.2 (-)
unnamed: C22.2, R31.2, U5.5 (+)
unnamed: C15.1, C23.2, U5.6 (-), U5.7
unnamed: C13.2, R23.2, U5.10 (+)
unnamed: C14.2, R30.1, U5.8, U5.9 (-)
unnamed: C20.2, R27.2, U5.12 (+)
unnamed: C12.1, C21.2, U5.13 (-), U5.14
unnamed: R42.2, U8.1, U8.3 (+), U8.5 (+), U8.12 (+)
unnamed: C24.1, R32.2, R33.1, U8.2 (-)
unnamed: R34.2, R35.2, R36.1, U8.6 (-)
unnamed: R41.2, R42.1, U8.10 (+)
unnamed: R39.1, R40.2, U8.9 (-)
unnamed: R37.2, R38.1, U8.13 (-)
unnamed: C2.2, R2.1, U9.3 (+)
unnamed: C5.2, R4.1, U9.5 (+)
unnamed: C1.2, R17.2, R18.1, U9.10 (+)
unnamed: R19.1, R21.1, U9.8, U9.9 (-)
unnamed: C18.1, R24.2, R25.1, U9.12 (+)

File MPXDecorder/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C18, C24, C30",0603,4,1u,
"C10, C11, C13, C14, C20, C21, C22, C23",0603,8,3.3n,
"C12, C15, C16, C17",1210,4,10u,
"C19, C25, C26, C27, C28, C29, C31, C6, C7, C9",0603,10,0.1u,
"C2, C3, C4, C5",C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal,4,0.01u,
C33,CP_Elec_10x10,1,330u 25v,
C8,0603,1,1n,
D1,0603,1,1s1588,
D2,LED_D3.0mm,1,STEREO-LED,
J1,PinHeader_1x03_P2.54mm_Vertical,1,MPX-IN,
J2,PinHeader_1x03_P2.54mm_Vertical,1,OUT-L,
J3,PinHeader_1x03_P2.54mm_Vertical,1,OUT-R,
"J4, J6, J7",PinHeader_1x03_P2.54mm_Vertical,3,GND,
J5,PinHeader_1x03_P2.54mm_Vertical,1,5V,
"Q1, Q2",TO-92_Inline,2,2SC1815,
"R1, R3",0603,2,7.5k,
"R10, R21, R43, R44, R45, R7, R9",0603,7,10k,
"R11, R46",0603,2,1k,
"R12, R14",0603,2,4.7k,
"R13, R17, R18, R24, R25, R32, R33, R5, R6",0603,9,100k,
"R15, R16",0603,2,39,
"R19, R20, R22, R23, R26, R27, R30, R31",0603,8,3.3k,
"R2, R4",0603,2,15k,
R28,0603,1,5.1k,
R29,0603,1,1.6k,
"R34, R35, R36, R37, R38, R39, R40, R41, R42",0603,9,47k,
R8,0603,1,20k,
RV1,Potentiometer_Bourns_3386P_Vertical,1,2k,
TP1,PinHeader_1x01_P1.00mm_Vertical,1,19KHz-Sin,
TP2,PinHeader_1x01_P1.00mm_Vertical,1,19KHz-Rect,
TP3,PinHeader_1x01_P1.00mm_Vertical,1,38KHz-PLL,
TP4,PinHeader_1x01_P1.00mm_Vertical,1,L+R,
TP5,PinHeader_1x01_P1.00mm_Vertical,1,L-R,
TP6,PinHeader_1x01_P1.00mm_Vertical,1,PILOT-V,
TP7,PinHeader_1x01_P1.00mm_Vertical,1,VCO,
U2,DIP-8_W7.62mm_Socket_LongPads,1,LM393,
U3,DIP-16_W7.62mm_Socket_LongPads,1,4046,
U4,DIP-14_W7.62mm_Socket_LongPads,1,74HC74,
"U5, U8, U9",DIP-14_W7.62mm_Socket_LongPads,3,HA17902,
U6,DIP-14_W7.62mm_Socket_LongPads,1,CD4066BE,

## KiCad design MPXDecorder-V2/MPXDecorder-V2.kicad_pcb

Parts:
C1, C5, C12, C36: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C6, C7, C8, C9, C13, C16, C19, C20, C21, C37, C38, C39: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C17, C18: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C10, C11, C14, C15: 0.01u; C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal
C23, C24, C25, C26, C29, C30, C31, C32: 2.2n; C_Rect_L7.0mm_W4.5mm_P5.00mm
C28: 330u 25v; CP_Elec_10x10
C33, C34: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D3, D4, D5, D6: 1s1588; D_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: STEREO-LED; LED_D3.0mm
J1: MPX-IN; PinHeader_1x03_P2.54mm_Vertical
J2: OUT-L; PinHeader_1x03_P2.54mm_Vertical
J3, J5, J7: GND; PinHeader_1x03_P2.54mm_Vertical
J4: OUT-R; PinHeader_1x03_P2.54mm_Vertical
J6: 5V; PinHeader_1x03_P2.54mm_Vertical
Q1, Q2, Q3: 2SC1815; TO-92_Inline
R1: 43k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3: 470k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R7, R9, R24, R26, R27, R32, R33, R35, R36, R37, R38, R39, R40, R41, R42, R45, R46: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R10, R43, R44, R47, R48, R53, R54, R55, R56: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R16, R23: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R20, R21, R30, R31, R34, R50, R51: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R28: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 680k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R22: 7.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R18: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R19, R25: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k; Potentiometer_Bourns_3386P_Vertical
RV2: 5k; Potentiometer_Bourns_3386P_Vertical
TP1: 19KHz-Sin; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP3: 19KHz-Rect; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP5: 38KHz-PLL; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP6: PILOT-V; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
TP7: VCO; TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded
U1: CD4066BE; DIP-14_W7.62mm_Socket_LongPads
U2: 4046; DIP-16_W7.62mm_Socket_LongPads
U3, U6, U7: upc458; DIP-14_W7.62mm_Socket_LongPads
U4: 74HC74; DIP-14_W7.62mm_Socket_LongPads
U5: LM393; DIP-8_W7.62mm_Socket_LongPads
U8: NJM4558; DIP-8_W7.62mm_Socket_LongPads

Connections:
+5V: C6.1, C13.1, C19.1, C20.1, C21.1, C28.1, C37.1, C38.1, C39.1, J6.1, J6.2, J6.3, R4.1, R5.1, R9.1, R11.1, R17.1, R20.1, R24.1, R30.1, R35.1, R36.1, R50.1, U1.4, U1.14 (V_{DD}), U2.16 (VDD), U3.4 (V+), U4.1 (~R), U4.4 (~S), U4.10 (~S), U4.13 (~R), U4.14 (VCC), U5.8 (V+), U6.4 (V+), U7.4 (V+), U8.8 (V+)
/19KHzRect: R36.2, TP3.1 (1_1), U2.14 (SigIn), U5.1
/19KHzSin: C2.1, C14.2, C16.1, R25.2, TP1.1 (1_1), U3.7
/38KHz-PLL: D3.2 (A), TP5.1 (1_1), U4.3 (C), U4.9 (Q)
/38KHz-PLL-INV: D5.2 (A), U4.8 (~Q), U4.12 (D)
/MONO-ENABLE: D4.2 (A), D6.2 (A), Q3.2 (C), R35.2
/MPX: C8.1, C12.1, Q1.2 (C), R3.2, R5.2
/OUT-L: C33.2, J2.1, J2.2, J2.3
/OUT-R: C34.2, J4.1, J4.2, J4.3
/PILOT-V: C9.1, R13.2, R14.1, TP6.1 (1_1), U5.5 (+)
/SIG-L: C29.2, R32.1, R37.1, U6.8, U6.9 (-)
/SIG-R: C30.2, R33.2, R40.1, U6.1, U6.2 (-)
/VCC/2: R41.2, R42.2, U7.3 (+), U7.8, U7.9 (-)
/VCO: TP7.1 (1_1), U2.4 (FOUT), U4.11 (C)
/VCO_ENABLE: R24.2, R34.1, U1.5, U1.6, U5.7
GND: C5.2, C6.2, C7.2, C9.2, C13.2, C17.2, C18.2, C19.2, C20.2, C21.2, C25.1, C26.1, C28.2, C31.1, C32.1, C36.2, C37.2, C38.2, C39.2, D2.1 (K), J3.1, J3.2, J3.3, J5.1, J5.2, J5.3, J7.1, J7.2, J7.3, Q2.1 (E), Q3.1 (E), R2.2, R6.2, R12.2, R14.2, R16.2, R18.2, R21.2, R23.2, R26.2, R27.2, R31.2, R51.2, RV1.3, U1.7 (V_{SS}), U1.9, U2.8 (VSS), U3.11 (V-), U4.7 (GND), U5.4 (V-), U6.11 (V-), U7.11 (V-), U8.4 (V-)
unnamed: C2.2, R7.1
unnamed: C8.2, R15.1
unnamed: C10.1, C11.1, R15.2, R16.1
unnamed: C10.2, R19.2, R22.1, U3.1
unnamed: C14.1, C15.1, R22.2, R23.1
unnamed: C23.1, R43.2, R47.1
unnamed: C24.1, R44.2, R48.1
unnamed: C29.1, R53.2, R55.1
unnamed: C30.1, R54.2, R56.1
unnamed: C33.1, R45.2, U7.14
unnamed: C34.1, R46.2, U7.7
unnamed: D1.2 (A), Q2.2 (C), R8.1, R9.2
unnamed: D1.1 (K), R13.1
unnamed: D2.2 (A), R28.2
unnamed: D3.1 (K), D4.1 (K), R26.1, U1.13
unnamed: D5.1 (K), D6.1 (K), R27.1, U1.12
unnamed: C1.1, J1.1, J1.2, J1.3
unnamed: C1.2, Q1.3 (B), R3.1
unnamed: Q1.1 (E), R6.1
unnamed: Q2.3 (B), R7.2, R8.2
unnamed: Q3.3 (B), R34.2
unnamed: R1.2, RV1.1, RV1.2
unnamed: R28.1, U1.3
unnamed: R38.1, R39.1, RV2.2, RV2.3, U7.1
unnamed: C3.1, U2.6 (C1)
unnamed: C3.2, U2.7 (C2)
unnamed: R4.2, U1.8, U2.5 (Inh)
unnamed: R10.1, U2.13 (PC2)
unnamed: R1.1, U2.11 (R1)
unnamed: R2.1, U2.12 (R2)
unnamed: U2.3 (RefIn), U4.5 (Q)
unnamed: C7.1, R10.2, U2.9 (VCOin)
unnamed: U3.3 (+), U3.5 (+), U3.13 (-), U3.14, U5.2 (-)
unnamed: C11.2, R19.1, U3.2 (-)
unnamed: C15.2, R25.1, U3.6 (-)
unnamed: C12.2, R20.2, R21.1, U3.10 (+)
unnamed: U1.1, U1.11, U3.8, U3.9 (-)
unnamed: C5.1, R11.2, R12.1, U3.12 (+)
unnamed: U4.2 (D), U4.6 (~Q)
unnamed: C16.2, R30.2, R31.1, U5.3 (+)
unnamed: R17.2, R18.1, U5.6 (-)
unnamed: C32.2, R56.2, U6.3 (+)
unnamed: C25.2, R47.2, U6.5 (+)
unnamed: C23.2, R53.1, U6.6 (-), U6.7
unnamed: C31.2, R55.2, U6.10 (+)
unnamed: C26.2, R48.2, U6.12 (+)
unnamed: C24.2, R54.1, U6.13 (-), U6.14
unnamed: R32.2, R33.1, RV2.1, U7.2 (-)
unnamed: R42.1, U7.5 (+)
unnamed: R39.2, R40.2, R46.1, U7.6 (-)
unnamed: C36.1, R50.2, R51.1, U7.10 (+)
unnamed: R41.1, U7.12 (+)
unnamed: R37.2, R38.2, R45.1, U7.13 (-)
unnamed: C17.1, U1.2, U8.3 (+)
unnamed: R43.1, U8.1, U8.2 (-)
unnamed: C18.1, U1.10, U8.5 (+)
unnamed: R44.1, U8.6 (-), U8.7

Notes on the sheet:
76k
19KHz BPF
Sallen-Key LPF fc=15kHz Q=0.707(Butterworth)
Limiter
STEREO-MONO SW
判定レベル：１．２ｖ
MATRIX
19KHz to 38KHz PLL

Board: 2 copper layers, 100.0 x 84.2 mm, 119 parts (55 on the bottom side), 73 nets.

File MPXDecorder-V2/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C12, C36, C5",0603,4,1u,
"C10, C11, C14, C15",C_Axial_L3.8mm_D2.6mm_P7.50mm_Horizontal,4,0.01u,
"C13, C16, C19, C2, C20, C21, C37, C38, C39, C6, C7, C8, C9",0603,13,0.1u,
"C17, C18, C3",0603,3,1n,
"C23, C24, C25, C26, C29, C30, C31, C32",C_Rect_L7.0mm_W4.5mm_P5.00mm,8,2.2n,
C28,CP_Elec_10x10,1,330u 25v,
"C33, C34",1206,2,10u,
"D1, D3, D4, D5, D6",0603,5,1s1588,
D2,LED_D3.0mm,1,STEREO-LED,
J1,PinHeader_1x03_P2.54mm_Vertical,1,MPX-IN,
J2,PinHeader_1x03_P2.54mm_Vertical,1,OUT-L,
"J3, J5, J7",PinHeader_1x03_P2.54mm_Vertical,3,GND,
J4,PinHeader_1x03_P2.54mm_Vertical,1,OUT-R,
J6,PinHeader_1x03_P2.54mm_Vertical,1,5V,
"Q1, Q2, Q3",TO-92_Inline,3,2SC1815,
R1,0603,1,43k,
"R10, R43, R44, R47, R48, R5, R53, R54, R55, R56",0603,10,4.7k,
"R11, R12, R20, R21, R30, R31, R34, R50, R51",0603,9,100k,
"R13, R28",0603,2,1k,
R14,0603,1,680k,
"R15, R22",0603,2,7.5k,
"R16, R23, R6",0603,3,47,
R17,0603,1,5.1k,
R18,0603,1,1.5k,
"R19, R25",0603,2,15k,
"R2, R3",0603,2,470k,
"R24, R26, R27, R32, R33, R35, R36, R37, R38, R39, R4, R40, R41, R45, R46, R7, R9",0603,17,10k,
R42,0603,1,1ok,
R8,0603,1,20k,
RV1,Potentiometer_Bourns_3386P_Vertical,1,10k,
RV2,Potentiometer_Bourns_3386P_Vertical,1,5k,
TP1,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,19KHz-Sin,
TP3,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,19KHz-Rect,
TP5,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,38KHz-PLL,
TP6,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,PILOT-V,
TP7,TestPoint_Loop_D2.54mm_Drill1.5mm_Beaded,1,VCO,
U1,DIP-14_W7.62mm_Socket_LongPads,1,CD4066BE,
U2,DIP-16_W7.62mm_Socket_LongPads,1,4046,
"U3, U6, U7",DIP-14_W7.62mm_Socket_LongPads,3,upc458,
U4,DIP-14_W7.62mm_Socket_LongPads,1,74HC74,
U5,DIP-8_W7.62mm_Socket_LongPads,1,LM393,
U8,DIP-8_W7.62mm_Socket_LongPads,1,NJM4558,

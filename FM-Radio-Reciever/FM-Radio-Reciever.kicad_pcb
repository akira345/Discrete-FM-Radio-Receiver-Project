# Repository akira345/Discrete-FM-Radio-Receiver-Project

File Readme.md:

これは何？
===

生成AIを用いて、専用ICを使用せず日本のワイドFM受信機を設計、自作するプロジェクトです。
可能な限り汎用品を用いて自作し、専用ICの内部構造や動作原理を学習することを目的に作成されました。

また、各種生成AIを使用し、現時点でどこまでアナログ回路の設計、および評価が可能か？を研究する目的でもあります。

## 成果

現時点で以下のものが試作、動作しています。

* FM フロントエンド
  * RF増幅段
  * 局部発振
  * ミキサー
* IF リミッターアンプ + クワドラチャ検波
  * 差動対４段
  * 汎用トランジスタと手巻きコイルによるクワドラチャ検波
* FM MPX 復調
  * 汎用PLL IC + OpAMP + アナログスイッチによるFMステレオの復調

## KiCad design FM-Radio-Reciever/FM-Radio-Reciever.kicad_pcb

Parts:
C1, C3, C6, C9, C16, C18, C19, C21, C22, C23, C24, C34, C41, C48, C49, C60: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2: 10p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4, C7, C12, C17, C20, C26, C28, C30, C35, C42, C45, C52, C53, C55, C57, C65: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 1p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8: 30p; ALPS_FM_PVC
C10, C11: 27p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C13, C29, C32, C36, C39, C44, C47, C50: 100p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15: 33p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C25: 47p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C33, C38: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C37, C40, C43, C46, C54, C56, C58, C64: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C51: 330u 25v; CP_Elec_10x10
C59: 2p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C61, C62, C63: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: FV1043; D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp
D2: TUNE_L; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: TUNE_H; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: TUNE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5, D6: 1N4148; D_SOD-323_HandSoldering
FB1, FB2, FB3: MPZ1608S601ATA00; L_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: ANT-IN; PinHeader_1x03_P2.54mm_Vertical
J2, J5, J8: GND; PinHeader_1x03_P2.54mm_Vertical
J4: 10.7MHz Filter; PinHeader_1x03_P2.54mm_Vertical
J6: MPX-OUT; PinHeader_1x03_P2.54mm_Vertical
J7: +5V; PinHeader_1x03_P2.54mm_Vertical
JP1, JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: AB-SWAP; SolderJumper-3_P1.3mm_Bridged12_RoundedPad1.0x1.5mm
L1: 56n; L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC
L2: 82n; L_Radial_L8.0mm_W8.0mm_P5.00mm_Neosid_SD8
Q1, Q2, Q3, Q4, Q5: 2SK3557; SOT-23_Handsoldering
Q6, Q12, Q16: MMBT3904; SOT-23
Q7, Q8, Q9, Q10, Q11, Q13, Q14, Q15: MMDT3904; SOT-363_SC-70-6
R1: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R11, R12, R68, R69, R70, R73, R77, R78, R79: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R74, R83: 1Meg; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R9, R20, R24, R25, R33, R35, R38, R45, R47, R53, R56, R63, R71, R72, R94, R95: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 9.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R6, R10, R22, R46, R93: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13, R23, R80, R81, R90, R91, R92: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 5.6k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 8.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R18, R19, R42, R61, R64: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21, R34: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R26: 390; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27, R36, R37, R44, R48, R54, R55, R62: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R30, R32, R39, R43, R49, R52, R57, R60: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29, R40, R50, R58, R65, R66: 22; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31, R41, R51, R59: 150; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R67: 330; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; not fitted
R75, R76: 33k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R82: 12k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R84, R85: 2.2Meg; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R86, R87, R88, R89: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 10k; Potentiometer_Bourns_TC33X_Vertical
SW1: AFC_SW; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
T1: 2.21u; IFT_7mmx7mm
T2: IFT_7mmx7mm
TP1: OSC; PinHeader_1x01_P2.54mm_Vertical
TP2: IF; PinHeader_1x01_P2.54mm_Vertical
TP3: SF; PinHeader_1x01_P2.54mm_Vertical
TP4: LPF_OUT; PinHeader_1x01_P2.54mm_Vertical
TP5: IF_OUT; PinHeader_1x01_P2.54mm_Vertical
TP6: VBU; PinHeader_1x01_P2.54mm_Vertical
TP7: VBL; PinHeader_1x01_P2.54mm_Vertical
TP8: VBias; PinHeader_1x01_P2.54mm_Vertical
TP9: AFC_BIAS; PinHeader_1x01_P2.54mm_Vertical
TP10: AFC_V; PinHeader_1x01_P2.54mm_Vertical
TP11: DB; PinHeader_1x01_P2.54mm_Vertical
TP12: DA; PinHeader_1x01_P2.54mm_Vertical
U1: LM393; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C51.1, C52.1, C53.1, C54.1, C65.1, FB1.1, FB2.1, FB3.1, J7.1, J7.2, J7.3, Q2.2 (D), Q6.3 (C), Q12.3 (C), R4.1, R9.1, R16.1, R29.1, R40.1, R50.1, R58.1, R65.1, R66.1, R71.1, R75.1, R76.1, R84.1, R85.1, R90.1, R91.1, R92.1, R95.2, RV1.1, U1.8 (V+)
/AFC_BIAS: C63.1, R71.2, R72.1, R74.2, SW1.1 (A), TP9.1 (1_1)
/AFC_V: C60.1, R68.1, SW1.2 (B)
/DA: C61.1, Q15.2 (B1), R69.2, R73.1, R74.1, R86.1, R88.1, TP12.1 (1_1)
/DB: C62.1, Q15.5 (B2), R70.2, R79.1, R83.1, R87.1, R89.1, TP11.1 (1_1)
/OA: C27.1, Q7.6 (C1), Q9.3 (C2), R21.2, R69.1
/OB: C33.1, Q7.3 (C2), Q9.6 (C1), R34.2, R42.1, R70.1
/Q_TANK: C5.2, C13.2, Q2.3 (G), R6.1, T1.2 (AB)
/S1A: C44.2, Q11.6 (C1), R39.2
/S1B: C50.1, Q11.3 (C2), R43.2
/S2A: C29.2, Q14.6 (C1), R57.2
/S2B: C36.1, Q14.3 (C2), R60.2
/S3A: C39.2, Q10.6 (C1), R28.2
/S3B: C47.1, Q10.3 (C2), R32.2
/S4A: C5.1, C22.1, C48.1, Q13.6 (C1), R49.2
/S4B: C23.1, C49.1, Q13.3 (C2), R52.2
/SF: C18.2, R23.1, TP3.1 (1_1)
/VBL: C17.1, R9.2, R10.1, R24.2, R33.2, TP7.1 (1_1)
/VBU: C7.1, R4.2, R5.1, R18.1, R19.2, TP6.1 (1_1)
/VBias: C28.1, Q6.2 (E), R22.1, R25.1, R35.1, R38.1, R45.1, R47.1, R53.1, R56.1, R63.1, TP8.1 (1_1)
/VTRIM: R83.2, RV1.2
GND: C2.2, C3.2, C4.2, C6.2, C7.2, C8.5, C11.2, C12.2, C13.1, C16.2, C17.2, C20.2, C21.2, C26.2, C27.2, C28.2, C30.2, C31.2, C33.2, C34.2, C35.2, C37.2, C38.2, C41.2, C42.2, C43.2, C45.2, C46.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, D1.2 (A), J2.1, J2.2, J2.3, J4.2, J5.1, J5.2, J5.3, J8.1, J8.2, J8.3, L1.2, Q16.2 (E), R1.2, R2.2, R3.2, R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R17.2, R20.2, R22.2, R26.2, R30.2, R31.1, R41.1, R46.2, R51.1, R59.1, R61.2, R64.2, R67.2, R72.2, R73.2, R77.1, R78.2, R79.2, R82.2, R93.2, RV1.3, T1.1 (AA), T2.3 (SA), U1.4 (V-)
unnamed: C8.4, C9.2, R3.1
unnamed: C4.1, C6.1, C14.1, FB1.2, L2.1
unnamed: C22.2, R14.1
unnamed: C23.2, R15.1
unnamed: C29.1, R25.2, R27.1
unnamed: C30.1, C31.1, R28.1, R29.2, R32.1
unnamed: C32.1, R35.2, R37.1
unnamed: C35.1, C37.1, R39.1, R40.2, R43.1
unnamed: C36.2, R36.2, R38.2
unnamed: C39.1, R45.2, R48.1
unnamed: C41.1, R44.2, R47.2
unnamed: C42.1, C43.1, R49.1, R50.2, R52.1
unnamed: C44.1, R53.2, R54.1
unnamed: C45.1, C46.1, R57.1, R58.2, R60.1
unnamed: C47.2, R55.2, R56.2
unnamed: C48.2, R61.1
unnamed: C49.2, R64.1
unnamed: C50.2, R62.2, R63.2
unnamed: C55.1, C56.1, R21.1, R65.2
unnamed: C57.1, C58.1, R34.1, R66.2
unnamed: C59.2, D1.1 (K), R68.2
unnamed: D2.2 (A), R90.2
unnamed: D2.1 (K), D6.1 (K), U1.1
unnamed: D3.2 (A), R91.2
unnamed: D3.1 (K), D5.1 (K), U1.7
unnamed: D4.2 (A), R92.2
unnamed: D4.1 (K), Q16.3 (C)
unnamed: D5.2 (A), D6.2 (A), R94.1, R95.1
unnamed: C1.1, J1.1, J1.2, J1.3
unnamed: J4.1, JP2.2 (B), R67.1
unnamed: J4.3, T2.5 (SB), TP2.1 (1_1)
unnamed: C40.2, J6.1, J6.2, J6.3
unnamed: C24.2, JP1.1 (A)
unnamed: JP1.2 (B), Q5.1 (S), R17.1
unnamed: C32.2, JP2.1 (A), R30.1, TP5.1 (1_1)
unnamed: JP3.1 (A), Q15.3 (C2), R76.2, R78.1
unnamed: JP3.3 (B), Q15.6 (C1), R75.2, R77.2
unnamed: C64.1, JP3.2 (C), SW1.3 (C), TP10.1 (1_1)
unnamed: C9.1, C15.2, L2.2, Q1.2 (D)
unnamed: C3.1, Q1.3 (G), R2.1
unnamed: C1.2, Q1.1 (S), R1.1
unnamed: C18.1, Q2.1 (S), R7.1
unnamed: C12.1, C16.1, FB2.2, Q3.2 (D), Q4.2 (D)
unnamed: C2.1, C8.3, C10.1, C59.1, L1.1, Q3.3 (G)
unnamed: C10.2, C11.1, C19.1, Q3.1 (S), R8.1
unnamed: C19.2, Q4.3 (G), R12.1
unnamed: C24.1, Q4.1 (S), R13.1, TP1.1 (1_1)
unnamed: C25.2, Q5.2 (D), T2.2 (AB)
unnamed: C14.2, C15.1, Q5.3 (G), R11.1
unnamed: C26.1, Q6.1 (B), R16.2, R20.1
unnamed: Q7.2 (B1), Q9.2 (B1), R14.2, R18.2
unnamed: Q7.1 (E1), Q7.4 (E2), Q8.6 (C1)
unnamed: Q7.5 (B2), Q9.5 (B2), R15.2, R19.1
unnamed: Q8.2 (B1), R23.2, R24.1
unnamed: Q8.1 (E1), Q8.4 (E2), R26.1
unnamed: C34.1, Q8.5 (B2), R33.1
unnamed: Q8.3 (C2), Q9.1 (E1), Q9.4 (E2)
unnamed: Q10.2 (B1), R27.2
unnamed: Q10.1 (E1), Q10.4 (E2), R31.2
unnamed: Q10.5 (B2), R36.1
unnamed: Q11.2 (B1), R37.2
unnamed: Q11.1 (E1), Q11.4 (E2), R41.2
unnamed: Q11.5 (B2), R44.1
unnamed: C38.1, Q12.1 (B), R42.2
unnamed: C40.1, Q12.2 (E), R46.1, TP4.1 (1_1)
unnamed: Q13.2 (B1), R48.2
unnamed: Q13.1 (E1), Q13.4 (E2), R51.2
unnamed: Q13.5 (B2), R55.1
unnamed: Q14.2 (B1), R54.2
unnamed: Q14.1 (E1), Q14.4 (E2), R59.2
unnamed: Q14.5 (B2), R62.1
unnamed: Q15.1 (E1), R80.1
unnamed: Q15.4 (E2), R81.1
unnamed: Q16.1 (B), R93.1, R94.2
unnamed: R80.2, R81.2, R82.1
unnamed: C20.1, C21.1, C25.1, FB3.2, T2.1 (AA)
unnamed: R84.2, R89.2, U1.3 (+)
unnamed: R86.2, U1.2 (-)
unnamed: R85.2, R88.2, U1.5 (+)
unnamed: R87.2, U1.6 (-)

Notes on the sheet:
ギルバートセル バイアス生成 (VBU:2.34v VBL:1.57v)
IF Limit Amp
バイアス生成 (2.12v)
10.7MHz 10mv pp 前段セラフィルから接続
Termination
ギルバートセル型 クワドラチャ検波
位相シフト LT1は中華ボビン(Aitendo T7X7KA 内径 5mm) に0.21mmを17T その後コアを調整
R67は調整時に実装
受信周波数：76-95MHz バリコン：10p-30p L2: 0.6mmを内径5mmで4ターン長さ3.3mm L1: 0.6mmを内径5mmで3ターン長さ2.3mm T2 ボビン：Aitendo T7X7KA 巻き数比3:1 27T:9T (0.21mm)
LPF

Board: 4 copper layers, 73.0 x 73.0 mm, 214 parts (52 on the bottom side), 102 nets.

File FM-Radio-Reciever/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C16, C18, C19, C21, C22, C23, C24, C3, C34, C41, C48, C49, C6, C60, C9",0603,16,1000p,
"C10, C11",0603,2,27p,
"C12, C17, C20, C26, C28, C30, C35, C4, C42, C45, C52, C53, C55, C57, C65, C7",0603,16,0.1u,
"C13, C29, C32, C36, C39, C44, C47, C50",0603,8,100p,
C14,0603,1,39p,
C15,0603,1,33p,
C2,0603,1,10p,
C25,0603,1,47p,
"C27, C33, C38",0603,3,220p,
"C31, C37, C40, C43, C46, C54, C56, C58, C64",0603,9,10u,
C5,0603,1,1p,
C51,CP_Elec_10x10,1,330u 25v,
C59,0603,1,2p,
"C61, C62, C63",0603,3,1u,
C8,ALPS_FM_PVC,1,30p,
D1,D_DO-35_SOD27_P2.54mm_Vertical_AnodeUp,1,FV1043,
D2,0603,1,TUNE_L,
D3,0603,1,TUNE_H,
D4,0603,1,TUNE,
"D5, D6",D_SOD-323_HandSoldering,2,1N4148,
"FB1, FB2, FB3",0603,3,MPZ1608S601ATA00,
J1,PinHeader_1x03_P2.54mm_Vertical,1,ANT-IN,
"J2, J5, J8",PinHeader_1x03_P2.54mm_Vertical,3,GND,
J4,PinHeader_1x03_P2.54mm_Vertical,1,10.7MHz Filter,
J6,PinHeader_1x03_P2.54mm_Vertical,1,MPX-OUT,
J7,PinHeader_1x03_P2.54mm_Vertical,1,+5V,
L1,L_Axial_L9.5mm_D4.0mm_P2.54mm_Vertical_Fastron_SMCC,1,56n,
L2,L_Radial_L8.0mm_W8.0mm_P5.00mm_Neosid_SD8,1,82n,
"Q1, Q2, Q3, Q4, Q5",SOT-23_Handsoldering,5,2SK3557,
"Q10, Q11, Q13, Q14, Q15, Q7, Q8, Q9",SOT-363_SC-70-6,8,MMDT3904,
"Q12, Q16, Q6",SOT-23,3,MMBT3904,
R1,0603,1,100,
"R10, R22, R46, R6, R93",0603,5,4.7k,
"R11, R12, R2, R68, R69, R70, R73, R77, R78, R79",0603,10,100k,
"R13, R23, R80, R81, R90, R91, R92",0603,7,470,
"R14, R15",0603,2,5.6k,
R16,0603,1,8.2k,
"R17, R18, R19, R42, R61, R64",0603,6,1k,
"R20, R24, R25, R33, R35, R38, R4, R45, R47, R53, R56, R63, R71, R72, R9, R94, R95",0603,17,10k,
"R21, R34",0603,2,1.5k,
R26,0603,1,390,
"R27, R36, R37, R44, R48, R54, R55, R62",0603,8,47,
"R28, R30, R32, R39, R43, R49, R52, R57, R60, R67",0603,10,330,
"R29, R40, R50, R58, R65, R66",0603,6,22,
"R3, R74, R83",0603,3,1Meg,
"R31, R41, R51, R59",0603,4,150,
R5,0603,1,9.1k,
"R7, R8",0603,2,2.2k,
"R75, R76",0603,2,33k,
R82,0603,1,12k,
"R84, R85",0603,2,2.2Meg,
"R86, R87, R88, R89",0603,4,47k,
RV1,Potentiometer_Bourns_TC33X_Vertical,1,10k,
SW1,SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm,1,AFC_SW,
T1,IFT_7mmx7mm,1,2.21u,
T2,IFT_7mmx7mm,1,IFT_7mmx7mm,
TP1,PinHeader_1x01_P2.54mm_Vertical,1,OSC,
TP10,PinHeader_1x01_P2.54mm_Vertical,1,AFC_V,
TP11,PinHeader_1x01_P2.54mm_Vertical,1,DB,
TP12,PinHeader_1x01_P2.54mm_Vertical,1,DA,
TP2,PinHeader_1x01_P2.54mm_Vertical,1,IF,
TP3,PinHeader_1x01_P2.54mm_Vertical,1,SF,
TP4,PinHeader_1x01_P2.54mm_Vertical,1,LPF_OUT,
TP5,PinHeader_1x01_P2.54mm_Vertical,1,IF_OUT,
TP6,PinHeader_1x01_P2.54mm_Vertical,1,VBU,
TP7,PinHeader_1x01_P2.54mm_Vertical,1,VBL,
TP8,PinHeader_1x01_P2.54mm_Vertical,1,VBias,
TP9,PinHeader_1x01_P2.54mm_Vertical,1,AFC_BIAS,
U1,SOIC-8_3.9x4.9mm_P1.27mm,1,LM393,

## KiCad design MPXDecorder-V4_SMD/MPXDecorder-V4_SMD.kicad_pcb

Parts:
C3, C5, C10, C42, C43: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C13, C14, C17, C18, C19, C24, C25, C26, C38, C40: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C20, C21: 470p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C22, C23: 390p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C27, C28: 4700p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C29, C30: 1200p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C31, C32: 180p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C33: 330u 25v; CP_Elec_10x10
C34, C35: 10u; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C36, C37: 220p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C41: 1n; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C50: 33n; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D2: STEREO-LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: MPX-IN; PinHeader_1x03_P2.54mm_Vertical
J2: OUT-L; PinHeader_1x03_P2.54mm_Vertical
J3, J5, J7: GND; PinHeader_1x03_P2.54mm_Vertical
J4: OUT-R; PinHeader_1x03_P2.54mm_Vertical
J6: 5V; PinHeader_1x03_P2.54mm_Vertical
Q3, Q4, Q5, Q6: 2N3904; SOT-23_Handsoldering
R1: 120k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 300k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R5, R12, R13, R22, R23: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24, R28, R30, R31: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33, R34, R35, R36, R38, R39, R44, R45, R46, R47, R48, R49, R52, R53, R60, R61, R62, R66, R67, R68, R72, R81, R82, R83: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R40, R41, R42, R43, R50, R51, R54, R55: 22k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R58: 1.5k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R63, R84: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R64: 68k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R69: 2.2Meg; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R70: 4.7Meg; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R71: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R80: 27k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R85: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RV1: 50k; Potentiometer_Bourns_TC33X_Vertical
RV2: 2.2k; Potentiometer_Bourns_TC33X_Vertical
TP3: 38KHz-PLL; TestPoint_Pad_2.5x2.5mm
TP5: VCO; TestPoint_Pad_2.5x2.5mm
TP6: VCO_IN; TestPoint_Pad_2.5x2.5mm
TP7: SA; TestPoint_Pad_2.5x2.5mm
TP8: SB; TestPoint_Pad_2.5x2.5mm
TP9: PD; TestPoint_Pad_2.5x2.5mm
TP10: Quadrature-phase; TestPoint_Pad_2.5x2.5mm
TP11: COMP; TestPoint_Pad_2.5x2.5mm
TP12: VCTL; TestPoint_Pad_2.5x2.5mm
U1, U8: TC4066BFELNF; SO-14_5.3x10.2mm_P1.27mm
U2, U6, U7: NJM2747V; SSOP-14_5.3x6.2mm_P0.65mm
U3: 74HC4046APW; TSSOP-16_4.4x5mm_P0.65mm
U4: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U5, U9: 74HC74D; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+5V: C7.1, C13.1, C14.1, C17.1, C18.1, C19.1, C24.1, C25.1, C26.1, C33.1, C38.1, J6.1, J6.2, J6.3, R4.1, R12.1, R22.1, R24.1, R28.1, R30.1, R31.1, R81.1, R83.1, U1.14 (V_{DD}), U2.4 (V+), U3.16 (VDD), U4.8 (V+), U5.1 (~R), U5.4 (~S), U5.10 (~S), U5.13 (~R), U5.14 (VCC), U6.4 (V+), U7.4 (V+), U8.14 (V_{DD}), U9.1 (~R), U9.2 (D), U9.3 (C), U9.4 (~S), U9.10 (~S), U9.13 (~R), U9.14 (VCC)
/38KHz-PLL: C37.2, R35.2, TP3.1 (1_1), U5.3 (C), U5.9 (Q)
/38KHz-PLL-INV: C36.2, R33.2, U5.8 (~Q), U5.12 (D), U9.11 (C)
/COMP: R60.1, R61.1, R71.2, TP11.1 (1_1), U1.1, U1.4, U1.8, U1.11, U2.8
/In-phase: U1.5, U5.5 (Q), U9.12 (D)
/In-phase_INV: U1.6, U5.2 (D), U5.6 (~Q)
/MONO: D2.1 (K), R83.2, U4.1, U8.5, U8.13
/MPX: C10.1, J1.1, J1.2, J1.3
/OUT-L: C34.2, J2.1, J2.2, J2.3
/OUT-R: C35.2, J4.1, J4.2, J4.3
/PD: R62.2, R63.1, R85.1, TP9.1 (1_1), U2.7
/Quadrature-phase: TP10.1 (1_1), U8.6, U9.9 (Q)
/SA: C42.1, R66.2, TP7.1 (1_1), U4.3 (+), U4.6 (-)
/SB: C43.1, R67.2, R68.2, TP8.1 (1_1)
/SIG-L: C29.2, R38.1, R44.1, U6.8, U6.9 (-)
/SIG-R: C30.2, R39.2, R47.1, U6.1, U6.2 (-)
/STEREO: R24.2, R34.2, R36.2, R70.2, U4.7
/VCC/2: R48.2, R49.2, U7.3 (+), U7.8, U7.9 (-)
/VCO: TP5.1 (1_1), U3.4 (FOUT), U5.11 (C)
/VCO-IN: C50.1, R80.2, R81.2, R82.1, TP6.1 (1_1), U3.9 (VCOin)
/VCTL: C40.2, C41.2, R80.1, R84.1, TP12.1 (1_1), U2.1
/VREF_2.5V: R72.1, U2.3 (+), U2.13 (-), U2.14, U8.9
GND: C3.2, C5.2, C7.2, C13.2, C14.2, C17.2, C18.2, C19.2, C22.1, C23.1, C24.2, C25.2, C26.2, C31.1, C32.1, C33.2, C38.2, C42.2, C43.2, C50.2, J3.1, J3.2, J3.3, J5.1, J5.2, J5.3, J7.1, J7.2, J7.3, Q4.2 (E), Q6.2 (E), R2.2, R5.2, R13.2, R23.2, R69.2, R82.2, RV1.2, RV1.3, U1.7 (V_{SS}), U2.11 (V-), U3.3 (RefIn), U3.5 (Inh), U3.8 (VSS), U3.14 (SigIn), U4.4 (V-), U5.7 (GND), U6.11 (V-), U7.11 (V-), U8.7 (V_{SS}), U8.10, U8.11, U8.12, U9.7 (GND)
unnamed: C20.1, R40.2, R42.1
unnamed: C21.1, R41.2, R43.1
unnamed: C27.2, C34.1, R52.2, U7.14
unnamed: C28.2, C35.1, R53.2, U7.7
unnamed: C29.1, R50.2, R54.1
unnamed: C30.1, R51.2, R55.1
unnamed: C40.1, R64.2
unnamed: D2.2 (A), R28.2
unnamed: C36.1, Q3.1 (B), R33.1
unnamed: Q3.3 (C), R30.2, U1.13
unnamed: Q3.2 (E), Q4.3 (C)
unnamed: Q4.1 (B), R34.1
unnamed: C37.1, Q5.1 (B), R35.1
unnamed: Q5.3 (C), R31.2, U1.12
unnamed: Q5.2 (E), Q6.3 (C)
unnamed: Q6.1 (B), R36.1
unnamed: R1.2, RV1.1
unnamed: R40.1, U1.2
unnamed: R41.1, U1.10
unnamed: R45.1, R46.1, R58.2, U7.1
unnamed: R58.1, RV2.2, RV2.3
unnamed: R66.1, U1.3
unnamed: R67.1, U1.9
unnamed: R84.2, U8.2
unnamed: R85.2, U8.4
unnamed: C41.1, R63.2, R64.1, U2.2 (-), U8.1, U8.3
unnamed: R60.2, U2.5 (+), U8.8
unnamed: R61.2, R62.1, U2.6 (-)
unnamed: C10.2, R22.2, R23.1, U2.10 (+)
unnamed: R71.1, R72.2, U2.9 (-)
unnamed: C5.1, R12.2, R13.1, U2.12 (+)
unnamed: C4.1, U3.6 (C1)
unnamed: C4.2, U3.7 (C2)
unnamed: R1.1, U3.11 (R1)
unnamed: R2.1, U3.12 (R2)
unnamed: R68.1, R69.1, R70.1, U4.2 (-), U4.5 (+)
unnamed: C32.2, R55.2, U6.3 (+)
unnamed: C22.2, R42.2, U6.5 (+)
unnamed: C20.2, R50.1, U6.6 (-), U6.7
unnamed: C31.2, R54.2, U6.10 (+)
unnamed: C23.2, R43.2, U6.12 (+)
unnamed: C21.2, R51.1, U6.13 (-), U6.14
unnamed: R38.2, R39.1, RV2.1, U7.2 (-)
unnamed: R49.1, U7.5 (+)
unnamed: C28.1, R46.2, R47.2, R53.1, U7.6 (-)
unnamed: C3.1, R4.2, R5.1, U7.10 (+)
unnamed: R48.1, U7.12 (+)
unnamed: C27.1, R44.2, R45.2, R52.1, U7.13 (-)

Notes on the sheet:
RV2(2.2k)+R58(1.5k) = Rf 1.5k〜3.7k（U7A 帰還） 予測最適 Rf：1.86k(38kHz誤差0°) / 2.0k(Vos typ) / 2.8k(Vos最悪) → RV2 単体で 0.4k〜1.3k 付近。実装前にピン1-2間を約0.5kに合わせておく 許容幅：±100Ωで約35dB、±50Ωで約40dB 漏れが主信号と同相→RV2を大きく、逆相→小さく
76k
Sallen-Key LPF fc=16kHz Q=0.707(4次Butterworth) 前段：Q=0.549 後段：Q=1.291
2.5V Ref
STEREO-MONO SW
100mV pp
MATRIX
